# Keil uVision project Pilotage Drone automatique.uvproj, settings and files
target kit (MCS-51)
  device: C8051F320 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(25000000)
  output: Pilotage Drone automatique
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: Pilotage Drone automatique.c
